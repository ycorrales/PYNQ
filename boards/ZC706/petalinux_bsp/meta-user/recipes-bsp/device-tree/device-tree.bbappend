SRC_URI:append = " file://system-user.dtsi"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
